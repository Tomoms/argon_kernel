## fs/notify/Kconfig
```kconfig
config FSNOTIFY
	def_bool n

source "fs/notify/inotify/Kconfig"
source "fs/notify/fanotify/Kconfig"
```
